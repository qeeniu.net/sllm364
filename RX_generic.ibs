[IBIS Ver]   5.0
[File Name]   RX_generic.ibs
[File Rev]   1.0
[Component]   RX_generic
[Manufacturer] My Company
[Package]
R_pkg  0.0   NA   NA
L_pkg  0.0   NA   NA
C_pkg  0.0   NA   NA
[Pin]   signal_name   model_name   R_pin L_pin  C_pin
2p   RX_generic_2p   RX_generic
2n   RX_generic_2n   RX_generic
[Diff_Pin] inv_pin vdiff tdelay_typ tdelay_min tdelay_max
2p   2n   NA   NA   NA   NA
[Model] RX_generic
Model_type Input
C_comp 0p 0p 0p
Vinh = 0.25
Vinl = -0.25
[Temperature_Range] 25 125 0
[Voltage Range] 1.0 1.0 1.0
[Algorithmic Model]
Executable Windows_cl16.00.30319.01_64 RX_generic_x64.dll RX_generic.ami
Executable Windows_cl16.00.30319.01_32 RX_generic.dll RX_generic.ami
[End Algorithmic Model]
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| Models and submodels in the file (1): RX_generic (Input)
